# Keil uVision project linedetection.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: linedetection
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ./inc
  asm include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: ir_sensor.c main.c LEDs.c adc.c motor.c timers.c LCD_4bit.c delay.c
  group inc
    ./inc/: adc.h gpio_defs.h ir_sensor.h LEDs.h motor.h timers.h lcd_4bit.h delay.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
